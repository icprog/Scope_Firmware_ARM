# Keil uVision project experimental_ble_app_hrs_advertiser_s130_pca10028.uvprojx, settings and files
target nrf51422_xxac_s130 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10028 S130 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 NRF_LOG_USES_UART=1
  c include: ..\..\..\config;..\..\..\..\components\ble\ble_advertising;..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\components\ble\common;..\..\..\..\components\ble\device_manager;..\..\..\..\components\drivers_nrf\common;..\..\..\..\components\drivers_nrf\config;..\..\..\..\components\drivers_nrf\delay;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\components\drivers_nrf\uart;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\components\libraries\fifo;..\..\..\..\components\libraries\fstorage;..\..\..\..\components\libraries\fstorage\config;..\..\..\..\components\libraries\sensorsim;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\trace;..\..\..\..\components\libraries\uart;..\..\..\..\components\libraries\util;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\softdevice\s130\headers;..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\components\ble\ble_services\ble_slope;..\..\..\..\components\ble\ble_services\ble_status;..\..\..\..\app;..\..\..\..\SeggerRTT;C:\Keil_v5\ARM\Pack\NordicSemiconductor\RTT;C:\Keil_v5\ARM\Pack\NordicSemiconductor\Syscalls;..\..\..\..\components\cal_services
  asm define: as above
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002080 size 0x5f80
  group Application
    ../../../: advertiser_beacon.c main.c app.c L3GD20drv.c LSM303drv.c SPI_utils.c probe_error.c profile_service.c calibration.c pcb_test.c timers.c debug.c
  group Board Support
    ../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../components/ble/device_manager/: device_manager_peripheral.c
    ../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../../../../components/ble/ble_services/ble_slope/: ble_slope.c
    ../../../../components/ble/ble_services/ble_status/: ble_status.c
    ../../../../components/cal_services/: cal_force.c cal_optical.c cal_vib.c cal_hall_effect.c
    ../../../: debug.c timers.c
  group nRF_Drivers
    ../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../components/libraries/fifo/: app_fifo.c
    ../../../../components/libraries/timer/: app_timer.c
    ../../../../components/libraries/trace/: app_trace.c
    ../../../../components/libraries/fstorage/: fstorage.c
    ../../../../components/libraries/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ../../../../components/softdevice/s130/doc/: s130_nrf51_2.0.0_licence_agreement.txt
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group RTT
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    C:/Keil_v5/ARM/PACK/NordicSemiconductor/Syscalls/: RTT_Syscalls_KEIL.c
  group Cal
    ../../../../components/cal_services/: cal_force.c cal_optical.c cal_vib.c cal_hall_effect.c
target flash_s130_nrf51_2.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: as above
  output: s130_nrf51_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002080 size 0x5f80
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
